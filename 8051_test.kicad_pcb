# Repository afiglee/8051header

## KiCad design 8051_test.kicad_pcb

Parts:
AVR-ISP1: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
C1, C2: 22; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 22.0x16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 10.0x16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DTR1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J2: Pwr; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_02x09_Odd_Even; PinHeader_2x09_P2.54mm_Vertical
J17: Prog; PinHeader_1x06_P2.54mm_Vertical
J24, J25: Conn_01x20_Pin; PinHeader_1x20_P2.54mm_Vertical
PwrCon1: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2: MMBT3906; SOT-23
Q3: 2N7002; SOT-23
Q4: Conn_02x02_Odd_Even; PinHeader_2x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R17: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R16: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 1.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 430; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RST1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
U1: 8051; DIP-40_W15.24mm_Socket_LongPads
Y1: Crystal; Crystal_HC49-U_Vertical

Connections:
+5V: AVR-ISP1.2 (VCC), C4.1, C5.1, J2.2, J17.4, PwrCon1.3, Q1.2 (E), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R12.1, R13.1, R17.1
/A8: J25.20, U1.21 (P2.0/A8)
/A9: J25.19, U1.22 (P2.1/A9)
/A10: J25.18, U1.23 (P2.2/A10)
/A11: J25.17, U1.24 (P2.3/A11)
/A12: J25.16, U1.25 (P2.4/A12)
/A13: J25.15, U1.26 (P2.5/A13)
/A14: J25.14, U1.27 (P2.6/A14)
/A15: J25.13, U1.28 (P2.7/A15)
/AD0: J4.1, J25.2, U1.39 (P0.0/AD0)
/AD1: J4.3, J25.3, U1.38 (P0.1/AD1)
/AD2: J4.5, J25.4, U1.37 (P0.2/AD2)
/AD3: J4.7, J25.5, U1.36 (P0.3/AD3)
/AD4: J4.9, J25.6, U1.35 (P0.4/AD4)
/AD5: J4.11, J25.7, U1.34 (P0.5/AD5)
/AD6: J4.13, J25.8, U1.33 (P0.6/AD6)
/AD7: J4.15, J25.9, U1.32 (P0.7/AD7)
/ALE: J25.11, U1.30 (ALE/PROG)
/DTR: DTR1.1, J17.1
/EA: J4.17, J25.10, R17.2, U1.31 (EA/VPP)
/MISO: AVR-ISP1.1 (MISO), J24.7, U1.7 (P1.6)
/MOSI: AVR-ISP1.4 (MOSI), J24.6, U1.6 (P1.5)
/P1.0: J24.1, U1.1 (P1.0/T2)
/P1.1: J24.2, U1.2 (P1.1/T2E)
/P1.2: J24.3, U1.3 (P1.2)
/P1.3: J24.4, U1.4 (P1.3)
/P1.4: J24.5, U1.5 (P1.4)
/P3.0: J17.3, J24.10, U1.10 (P3.0/RxD)
/P3.1: J17.2, J24.11, U1.11 (P3.1/TxD)
/P3.2: J24.12, U1.12 (P3.2/INT0)
/P3.3: J24.13, U1.13 (P3.3/INT1)
/P3.4: J24.14, U1.14 (P3.4/T0)
/P3.5: J24.15, U1.15 (P3.5/T1)
/PSEN: J25.12, U1.29 (PSEN)
/RD: J24.17, U1.17 (P3.7/RD)
/RST: AVR-ISP1.5 (~RST), J24.9, RST1.1, U1.9 (RST)
/SCK: AVR-ISP1.3 (SCK), J24.8, U1.8 (P1.7)
/VPP: J25.1, PwrCon1.2, U1.40 (V+)
/WR: J24.16, U1.16 (P3.6/WR)
/X1: J24.18, Q4.2, U1.18 (XTAL1)
/X2: J24.19, Q4.4, U1.19 (XTAL2)
GND: AVR-ISP1.6 (GND), C1.2, C2.2, C5.2, D1.1 (K), J2.1, J4.18, J17.6, J24.20, Q2.3 (C), Q3.2 (S), R9.2, R11.2, R16.2, U1.20 (GND)
unnamed: C4.2, R9.1, R10.2
unnamed: D1.2 (A), R12.2
unnamed: DTR1.2, Q3.1 (G), R15.2, R16.1
unnamed: J4.2, R1.1
unnamed: J4.4, R2.1
unnamed: J4.6, R3.1
unnamed: J4.8, R4.1
unnamed: J4.10, R5.1
unnamed: J4.12, R6.1
unnamed: J4.14, R7.1
unnamed: J4.16, R8.1
unnamed: PwrCon1.1, Q1.3 (C), Q2.2 (E), R11.1
unnamed: Q1.1 (B), R13.2, R14.2
unnamed: Q2.1 (B), R15.1
unnamed: Q3.3 (D), R14.1
unnamed: C1.1, Q4.1, Y1.1
unnamed: C2.1, Q4.3, Y1.2
unnamed: R10.1, RST1.2

Board: 2 copper layers, 50.0 x 56.0 mm, 37 parts (0 on the bottom side), 60 nets.

## KiCad design 8051header.kicad_pcb

Board: 2 copper layers, 56.0 x 70.0 mm, 40 parts (0 on the bottom side), 60 nets.

Parts:
AVR-ISP1: AVR-ISP-6; IDC-Header_2x03_P2.54mm_Vertical
C1, C2: 22; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 22.0x16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 10.0x16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DTR1: Prog; PinHeader_1x02_P2.54mm_Vertical
J1: GND; PinHeader_1x02_P2.54mm_Vertical
J2: +5V; PinHeader_1x02_P2.54mm_Vertical
J3: PL2; PinHeader_1x20_P2.54mm_Vertical
J4: Rs; PinHeader_2x09_P2.54mm_Vertical
J5: PR2; PinHeader_1x20_P2.54mm_Vertical
J17: UART; PinHeader_1x06_P2.54mm_Vertical
J24: PL1; PinHeader_1x20_P2.54mm_Vertical
J25: PR1; PinHeader_1x20_P2.54mm_Vertical
Q1, Q2: MMBT3906; SOT-23
Q3: 2N7002; SOT-23
Q4: Conn Crystal; PinHeader_2x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R17: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R16: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 1.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15: 430; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RST1: Reset; PinHeader_1x02_P2.54mm_Vertical
SW1: SW_SPDT; SPDT_Omron_D2F_5pins
U1: 8051; DIP_Socket-40_W11.9_W12.7_W15.24_W17.78_W18.5_3M_240-1280-0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
Y1: 11.0592; Crystal_HC49-U_Vertical

Connections:
+5V: AVR-ISP1.2 (VCC), C4.1, C5.1, J2.1, J2.2, J17.4, Q1.2 (E), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R12.1, R13.1, R17.1, SW1.1 (A)
/A8: J5.20, J25.20, U1.21 (P2.0/A8)
/A9: J5.19, J25.19, U1.22 (P2.1/A9)
/A10: J5.18, J25.18, U1.23 (P2.2/A10)
/A11: J5.17, J25.17, U1.24 (P2.3/A11)
/A12: J5.16, J25.16, U1.25 (P2.4/A12)
/A13: J5.15, J25.15, U1.26 (P2.5/A13)
/A14: J5.14, J25.14, U1.27 (P2.6/A14)
/A15: J5.13, J25.13, U1.28 (P2.7/A15)
/AD0: J4.1, J5.2, J25.2, U1.39 (P0.0/AD0)
/AD1: J4.3, J5.3, J25.3, U1.38 (P0.1/AD1)
/AD2: J4.5, J5.4, J25.4, U1.37 (P0.2/AD2)
/AD3: J4.7, J5.5, J25.5, U1.36 (P0.3/AD3)
/AD4: J4.9, J5.6, J25.6, U1.35 (P0.4/AD4)
/AD5: J4.11, J5.7, J25.7, U1.34 (P0.5/AD5)
/AD6: J4.13, J5.8, J25.8, U1.33 (P0.6/AD6)
/AD7: J4.15, J5.9, J25.9, U1.32 (P0.7/AD7)
/ALE: J5.11, J25.11, U1.30 (ALE/PROG)
/DTR: DTR1.1, J17.1
/EA: J4.17, J5.10, J25.10, R17.2, U1.31 (EA/VPP)
/MISO: AVR-ISP1.1 (MISO), J3.7, J24.7, U1.7 (P1.6)
/MOSI: AVR-ISP1.4 (MOSI), J3.6, J24.6, U1.6 (P1.5)
/P1.0: J3.1, J24.1, U1.1 (P1.0/T2)
/P1.1: J3.2, J24.2, U1.2 (P1.1/T2E)
/P1.2: J3.3, J24.3, U1.3 (P1.2)
/P1.3: J3.4, J24.4, U1.4 (P1.3)
/P1.4: J3.5, J24.5, U1.5 (P1.4)
/P3.0: J3.10, J17.3, J24.10, U1.10 (P3.0/RxD)
/P3.1: J3.11, J17.2, J24.11, U1.11 (P3.1/TxD)
/P3.2: J3.12, J24.12, U1.12 (P3.2/INT0)
/P3.3: J3.13, J24.13, U1.13 (P3.3/INT1)
/P3.4: J3.14, J24.14, U1.14 (P3.4/T0)
/P3.5: J3.15, J24.15, U1.15 (P3.5/T1)
/PSEN: J5.12, J25.12, U1.29 (PSEN)
/RST: AVR-ISP1.5 (~RST), J3.9, J24.9, RST1.1, U1.9 (RST)
/SCK: AVR-ISP1.3 (SCK), J3.8, J24.8, U1.8 (P1.7)
/VPP: J5.1, J25.1, SW1.2 (B), U1.40 (V+)
/X1: J3.18, J24.18, Q4.2, U1.18 (XTAL1)
/X2: J3.19, J24.19, Q4.4, U1.19 (XTAL2)
/~RD: J3.17, J24.17, U1.17 (P3.7/RD)
/~WR: J3.16, J24.16, U1.16 (P3.6/WR)
GND: AVR-ISP1.6 (GND), C1.2, C2.2, C5.2, D1.1 (K), J1.1, J1.2, J3.20, J4.18, J17.6, J24.20, Q2.3 (C), Q3.2 (S), R9.2, R11.2, R16.2, U1.20 (GND)
unnamed: C4.2, R9.1, R10.2
unnamed: D1.2 (A), R12.2
unnamed: DTR1.2, Q3.1 (G), R15.2, R16.1
unnamed: J4.2, R1.1
unnamed: J4.4, R2.1
unnamed: J4.6, R3.1
unnamed: J4.8, R4.1
unnamed: J4.10, R5.1
unnamed: J4.12, R6.1
unnamed: J4.14, R7.1
unnamed: J4.16, R8.1
unnamed: Q1.1 (B), R13.2, R14.2
unnamed: Q1.3 (C), Q2.2 (E), R11.1, SW1.3 (C)
unnamed: Q2.1 (B), R15.1
unnamed: Q3.3 (D), R14.1
unnamed: C1.1, Q4.1, Y1.1
unnamed: C2.1, Q4.3, Y1.2
unnamed: R10.1, RST1.2

## Commit log

2023-09-28 Work in progress
2024-06-23 Finished Ver 1.0
2025-04-23 Corrected RX/TX pins
2025-04-28 Corrected transistors foot print; RX/TX already corrected; ver 1.1
2025-07-29 Updated to next version using ZIF socket
2025-07-29 Renamed files
2025-07-29 Added github reference
